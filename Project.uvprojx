# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Cfg;.\Core;.\Port;.\Start;.\User;.\SEGGER
  asm include: .\Cfg;.\Core;.\Port;.\Start;.\User
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Core
    ./Core/: os.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.c ucos_ii.h
  group Port
    ./Port/: os_cpu.h os_cpu_c.c os_cpu_a.s
  group Cfg
    ./Cfg/: app_cfg.h os_cfg.h
  group Start
    ./Start/: startup_stm32f401xx.s core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group User
    ./User/: main.c Cfg.h Init.h Init.c Tool.h Tool.c ISR.c Task.h Task.c
  group SEGGER
    ./SEGGER/: Global.h os_cfg_trace.h os_trace_events.h SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Config_uCOSII.c SEGGER_SYSVIEW_Int.h SEGGER_SYSVIEW_uCOSII.c
